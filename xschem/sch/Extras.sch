v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
L 4 -170 -110 -170 40 {}
L 4 -170 -110 170 -110 {}
L 4 -170 40 -170 110 {}
L 4 -170 110 170 110 {}
L 4 170 -110 170 110 {}
C {proyecto-IPD413/xschem/TB/gm_vs_W.sym} 0 -60 0 0 {name=x1}
C {proyecto-IPD413/xschem/TB/TB_lvmos_Cdrain.sym} 0 0 0 0 {name=x2}
C {proyecto-IPD413/xschem/TB/TB_lvmos_Cgate.sym} -40 40 0 0 {name=x3}
