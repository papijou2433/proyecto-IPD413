v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
L 4 -200 -50 -200 100 {}
L 4 -200 -50 140 -50 {}
C {../TB/gm_vs_W.sym} -20 0 0 0 {name=x1}
C {../TB/TB_lvmos_Cdrain.sym} -20 60 0 0 {name=x2}
